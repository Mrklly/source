# IAR project temperature_rf.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L136K8TA HDSC HC32L136K8TA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\startup; ..\user; ..\stdlib\inc; ..\driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: temperature_rf.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\startup; ..\source; ..\stdlib\inc; ..\driver
  OBJCOPY.OOCOutputFile: temperature_rf.srec
  group driver
    ../driver/: adc.c cmt2300a.c drv_eeprom.c drv_ir.c drv_seglcd.c key.c led.c spi.c spi_soft.c system.c timer.c uart.c
  group startup
    ../startup/: startup_hc32l136.s system_hc32l136.c
  group stdlib
    ../stdlib/src/: hc32_adc.c hc32_bt.c hc32_ddl.c hc32_flash.c hc32_gpio.c hc32_it.c hc32_lcd.c hc32_lpm.c hc32_lpuart.c hc32_spi.c hc32_sysctrl.c hc32_timer3.c hc32_uart.c hc32_wdt.c
  group user
    ../user/: control.c eeprom.c global_variables.c ir_parse.c ir_study.c key_handler.c lcd.c main.c modbus_rtu.c temperature.c wireless.c
