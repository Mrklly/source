# IAR project breath_led_485.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ..\project; ..\library\inc; ..\user\gpio; ..\user\statekey; ..\user\flash; ..\user\eeprom; ..\user\uart; ..\user\timer; ..\user\thirdagreement; ..\user\wwdg; ..\user\pwm
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: breath_led_485.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: ..\project; ..\library\inc; ..\user\gpio; ..\user\statekey; ..\user\flash; ..\user\eeprom; ..\user\uart; ..\user\timer; ..\user\thirdagreement; ..\user\wwdg
  OBJCOPY.OOCOutputFile: breath_led_485.s19
  ILINK.IlinkOutputFile: breath_led_485.out
  group (top)
    ./: eeprom.c global_variable.c key_handler.c main.c stm8s_it.c
  group library
    ../Library/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c stm8s_wwdg.c
  group user
    ../User/EEPROM/: bsp_e2p.c
    ../User/FLASH/: bsp_flash.c
    ../User/GPIO/: bsp_gpio.c
    ../User/StateKey/: bsp_key.c
    ../User/PWM/: bsp_pwm.c
    ../User/timer/: bsp_timer.c
    ../User/UART/: bsp_uart.c
    ../User/WWDG/: bsp_wwdg.c
    ../User/ThirdAgreement/: Third_agreement .c
