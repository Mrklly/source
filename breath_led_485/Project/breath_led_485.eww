<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\breath_led_485.ewp</path>
    </project>
    <batchBuild />
</workspace>
