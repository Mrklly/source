# IAR project ir_rx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32F005C6PA HDSC HC32F005C6PA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\driver; ..\stdlib\inc; ..\user; ..\startup
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ir_rx.hex
  ILINK.IlinkOutputFile: ir_rx.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group driver
    ../driver/: drv_clock.c drv_infrared.c drv_led.c drv_spi_soft.c drv_timer.c drv_uart.c
  group startup
    ../startup/: startup_hc32f005.s system_hc32f005.c
  group stdlib
    ../stdlib/src/: hc32_bt.c hc32_clk.c hc32_ddl.c hc32_flash.c hc32_gpio.c hc32_it.c hc32_reset.c hc32_trim.c hc32_uart.c hc32_wdt.c
  group user
    ../user/: cmt2300.c global_variables.c infrared.c main.c modbus_rtu.c
