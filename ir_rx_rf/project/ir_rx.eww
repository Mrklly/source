<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ir_rx.ewp</path>
    </project>
    <batchBuild />
</workspace>
