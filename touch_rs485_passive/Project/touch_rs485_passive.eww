<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\touch_rs485_passive.ewp</path>
  </project>
  <batchBuild/>
</workspace>


