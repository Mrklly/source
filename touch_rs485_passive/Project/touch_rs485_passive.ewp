# IAR project touch_rs485_passive.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x200
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ..\User\GPIO; ..\User\StateKey; ..\User\FLASH; ..\Project; ..\Librarise\STM8S_StdPeriph_Driver\inc; ..\User\UART; ..\User\timer; ..\User\WWDG
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: touch_rs485_passive.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\我的资料\调试项目\我的项目\bighalo v1.1带协议\Librarise\STM8S_StdPeriph_Driver\inc; D:\我的资料\调试项目\我的项目\bighalo v1.1带协议\User\GPIO; D:\我的资料\调试项目\我的项目\bighalo v1.1带协议\User\KEY; D:\我的资料\调试项目\我的项目\bighalo v1.1带协议\Project; D:\我的资料\调试项目\我的项目\bighalo v1.1带协议\User\UART; D:\我的资料\调试项目\我的项目\bighalo v1.1带协议\User\EEPROM; D:\我的资料\调试项目\我的项目\bighalo v1.1带协议\User\FLASH; D:\我的资料\调试项目\我的项目\bighalo v1.1带协议\User\ThirdAgreement; D:\我的资料\调试项目\我的项目\bighalo v1.1带协议\User\timer; D:\我的资料\调试项目\我的项目\bighalo v1.1带协议\User\WWDG
  OBJCOPY.OOCOutputFile: 日顺RCU弱电485协议.s19
  ILINK.IlinkOutputFile: BigRing_STM8S003K3T6.out
  group (top)
    ./: global_variable.c main.c protocol_shanghui.c stm8s_it.c
  group Lib
    ../Librarise/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c stm8s_wwdg.c
  group User
    ../User/FLASH/: bsp_flash.c
    ../User/GPIO/: bsp_gpio.c
    ../User/StateKey/: bsp_key.c
    ../User/timer/: bsp_timer.c
    ../User/UART/: bsp_uart.c
    ../User/WWDG/: bsp_wwdg.c
