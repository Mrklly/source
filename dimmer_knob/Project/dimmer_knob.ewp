# IAR project dimmer_knob.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L136J8TA HDSC HC32L136J8TA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\Librarise\inc; ..\start_up; ..\User\lcd; ..\User\UART; ..\User\FLASH; ..\User\GPIO; ..\User\RS485Agreement; ..\User\timer; ..\User\KEY; ..\User\PWM; ..\User\SYS; ..\User\interrupt; ..\User\knob; ..\Project
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: global_variables.c knob_handler.c main.c
  group lib
    ../Librarise/src/: adc.c adt.c aes.c bgr.c bt.c crc.c ddl.c debug.c dmac.c flash.c gpio.c hdiv.c i2c.c interrupts_hc32l13x.c lcd.c lpm.c lpt.c lpuart.c lvd.c opa.c pca.c pcnt.c reset.c rng.c rtc.c spi.c sysctrl.c timer3.c trim.c uart.c vc.c wdt.c
  group start_up
    ../start_up/: startup_hc32l13x.s system_hc32l13x.c
  group user
    ../User/FLASH/: bsp_flash.c
    ../User/GPIO/: bsp_gpio.c
    ../User/interrupt/: bsp_it.c
    ../User/KEY/: bsp_key.c
    ../User/PWM/: bsp_pwm.c
    ../User/SYS/: bsp_system.c
    ../User/timer/: bsp_timer.c
    ../User/UART/: bsp_uart.c
    ../User/knob/: drv_knob.c
    ../User/RS485Agreement/: RS485_Agreement.c
