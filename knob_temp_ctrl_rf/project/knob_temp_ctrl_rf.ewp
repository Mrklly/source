# IAR project knob_temp_ctrl_rf.ewp, settings and files
configuration Knob (ARM, debug)
  General.OGChipSelectEditMenu: HC32L136K8TA HDSC HC32L136K8TA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; TEMP_CTRL_KNOB=1; TEMP_CTRL_TOUCH=0
  ICCARM.CCIncludePath2: ..\startup; ..\user; ..\stdlib\inc; ..\driver; ..\tuya
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: temp_ctrl_knob.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Touch (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __DEBUG; TEMP_CTRL_KNOB=0; TEMP_CTRL_TOUCH=1
  OBJCOPY.OOCOutputFile: temp_ctrl_touch.hex
  group driver
    ../driver/: adc.c cmt2300a.c drv_eeprom.c drv_ir.c drv_it.c drv_knob.c drv_led.c drv_near_check.c drv_seglcd.c drv_sys.c drv_wdt.c key.c spi.c spi_soft.c timer.c uart.c
  group startup
    ../startup/: startup_hc32l136.s system_hc32l136.c
  group stdlib
    ../stdlib/src/: hc32_adc.c hc32_bt.c hc32_ddl.c hc32_flash.c hc32_gpio.c hc32_it.c hc32_lcd.c hc32_lpm.c hc32_lpuart.c hc32_spi.c hc32_sysctrl.c hc32_timer3.c hc32_uart.c hc32_wdt.c
  group tuya
    ../tuya/: mcu_api.c protocol.c system.c
  group user
    ../user/: control.c eeprom.c global_variables.c ir_parse.c ir_study.c key_handler.c knob_handler.c lcd.c main.c modbus_rtu.c temperature.c timing_task.c wireless.c
    ../driver/: led.c
