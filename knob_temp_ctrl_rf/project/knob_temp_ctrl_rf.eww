<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\knob_temp_ctrl_rf.ewp</path>
    </project>
    <batchBuild />
</workspace>
