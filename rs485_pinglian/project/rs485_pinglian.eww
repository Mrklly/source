<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\rs485_pinglian.ewp</path>
    </project>
    <batchBuild />
</workspace>
