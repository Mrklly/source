# IAR project rs485_pinglian.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L130J8TA HDSC HC32L130J8TA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\stdlib\inc; ..\startup; ..\driver; ..\user
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: QB502_522_811_DC.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group driver
    ../driver/: bsp_flash.c bsp_gpio.c bsp_it.c bsp_key.c bsp_pwm.c bsp_system.c bsp_timer.c bsp_uart.c
  group start_up
    ../startup/: startup_hc32l13x.s system_hc32l13x.c
  group stdlib
    ../stdlib/src/: hc32_adt.c hc32_bt.c hc32_ddl.c hc32_flash.c hc32_gpio.c hc32_it.c hc32_lpuart.c hc32_reset.c hc32_sysctrl.c hc32_timer3.c hc32_uart.c hc32_wdt.c
  group user
    ../user/: eeprom.c global_variables.c key_handler.c led_dimmer.c main.c modbus_rtu.c panel_control.c protocol_passive.c
