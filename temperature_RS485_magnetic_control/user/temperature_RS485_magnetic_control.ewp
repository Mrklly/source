# IAR project temperature_RS485_magnetic_control.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\lib\inc; ..\lib\src; ..\user; ..\drive
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: temperature.hex
  ILINK.IlinkOutputFile: bighalo.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s003k3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: temperature_RS485_magnetic_control.bin
  ILINK.IlinkOutputFile: switch.out
  group drive
    ../drive/: adc.c e2p.c flash.c ht1621.c key.c led.c stm8s_interruput.c temperature.c uart.c wwdg.c
  group lab
    ../lib/src/: stm8s_adc1.c stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_rst.c stm8s_uart1.c stm8s_wwdg.c
  group user
    ./: global_variables.c key_handler.c main.c modbus_rtu.c system_timer.c
